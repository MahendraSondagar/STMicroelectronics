# IAR project Project.ewp, settings and files
configuration STM32L4R9ZI-SensorTileBox (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; STM32_SENSORTILEBOX; SENSING1_BlueNRG2; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Patch; ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\SensorTile.box; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox; ..\..\..\..\..\Drivers\BSP\Components\lis3dhh; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_AI_AudioPreprocessing_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\Middlewares\ST\BlueNRG2\includes; ..\..\..\..\..\Middlewares\ST\BlueNRG2\hci\hci_tl_patterns\Basic; ..\..\..\..\..\Middlewares\ST\BlueNRG2\utils; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: SENSING1.bin
  ILINK.IlinkOutputFile: SENSING1_ST101.out
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Drivers\CMSIS\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_audio.c SensorTile.box_bc.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_env_sensors_ex.c SensorTile.box_motion_sensors.c SensorTile.box_motion_sensors_ex.c SensorTile.box_sd.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/BlueNRG2/Controller
    ../../../../../Middlewares/ST/BlueNRG2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Middlewares/BlueNRG2/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG2/Utils
    ../../../../../Middlewares/ST/BlueNRG2/utils/: ble_list.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_AI_AudioPreprocessing_Library
    ../../../../../Middlewares/ST/STM32_AI_AudioPreprocessing_Library/Src/: common_tables.c dct.c feature_extraction.c mel_filterbank.c window.c
  group Middlewares/STM32_AI_Library
    ../../../../../Middlewares/ST/STM32_AI_Library/lib/: NetworkRuntime410_CM4_IAR.a
  group SENSING1/EWARM
    ./: startup_stm32l4r9xx.s
  group SENSING1/User
    ../Src/: ai_common.c cli_commands.c DataLog_Manager.c FreeRTOS_CLI.c hci_tl_interface.c HWAdvanceFeatures.c main.c OTA.c PowerControl.c sd_diskio_SensorTile.box.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c
  group SENSING1/User/ASC
    ../Src/: asc.c asc_data.c asc_featurescaler.c asc_postprocessing.c asc_processing.c
  group SENSING1/User/HAR
    ../Src/: har_gmp.c har_gmp_data.c har_ign.c har_ign_data.c har_ign_wsdm.c har_ign_wsdm_data.c har_Postprocessing.c har_Preprocessing.c har_Processing.c har_ProcessingTest.c
