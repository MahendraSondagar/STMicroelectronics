# Keil uVision project Project.uvprojx, settings and files
target SENSING1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: SENSING1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,STM32_SENSORTILEBOX,ARM_MATH_CM4,__FPU_PRESENT=1,SENSING1_BlueNRG2
  c misc: --no_conditionalize --diag_suppress 1
  c include: ../Inc;../Patch;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/DSP/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/SensorTile.box;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lis2mdl;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/lsm6dsox;../../../../../Middlewares/ST/STM32_AI_Library/Inc;../../../../../Middlewares/ST/STM32_AI_AudioPreprocessing_Library/Inc;../../../../../Middlewares/ST/STM32_MetaDataManager;../../../../../Middlewares/ST/BlueNRG2/includes;../../../../../Middlewares/ST/BlueNRG2/hci/hci_tl_patterns/Basic;../../../../../Middlewares/ST/BlueNRG2/utils;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  link misc: --diag_suppress=L6329  --diag_suppress L6989
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: arm_dot_prod_f32.c arm_negate_q15.c arm_add_q7.c arm_shift_q15.c arm_shift_q7.c arm_mult_f32.c
  group Drivers/CMSIS/DSP/Source/SupportFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/SupportFunctions/: arm_float_to_q7.c arm_float_to_q15.c arm_q7_to_float.c arm_q15_to_float.c arm_q7_to_q15.c arm_q15_to_q7.c arm_copy_q15.c arm_copy_q7.c arm_fill_q7.c arm_fill_q15.c
  group Drivers/CMSIS/DSP/Source/MatrixFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_init_f32.c
  group Drivers/CMSIS/DSP/Source/TransformFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_fast_init_f32.c arm_rfft_fast_f32.c arm_bitreversal.c arm_cfft_f32.c arm_cfft_radix8_f32.c arm_bitreversal2.S
  group Drivers/CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_squared_f32.c
  group Drivers/CMSIS/DSP/Source/CommonTables
    ../../../../../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
  group User/SENSING1
    ../Src/: stm32l4xx_it.c main.c DataLog_Manager.c hci_tl_interface.c HWAdvanceFeatures.c OTA.c PowerControl.c sd_diskio_SensorTile.box.c sensor_service.c stm32l4xx_hal_msp.c TargetPlatform.c ai_common.c cli_commands.c FreeRTOS_CLI.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_audio.c SensorTile.box_bc.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_env_sensors_ex.c SensorTile.box_motion_sensors.c SensorTile.box_motion_sensors_ex.c SensorTile.box_sd.c
  group Middlewares/BlueNRG2
    ../../../../../Middlewares/ST/BlueNRG2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
    ../../../../../Middlewares/ST/BlueNRG2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../Middlewares/ST/BlueNRG2/utils/: ble_list.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_AI_AudioPreprocessing_Library
    ../../../../../Middlewares/ST/STM32_AI_AudioPreprocessing_Library/Src/: common_tables.c feature_extraction.c mel_filterbank.c window.c dct.c
  group User/SENSING1_ASC
    ../Src/: asc_postprocessing.c asc_featurescaler.c asc_processing.c asc.c asc_data.c
  group User/SENSING1_HAR
    ../Src/: har_Postprocessing.c har_Preprocessing.c har_Processing.c har_ProcessingTest.c har_gmp.c har_gmp_data.c har_ign.c har_ign_data.c har_ign_wsdm.c har_ign_wsdm_data.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_ll_sdmmc.c
  group Middlewares/STM32_AI_Library
    ../../../../../Middlewares/ST/STM32_AI_Library/Lib/: NetworkRuntime410_CM4_Keil.lib
