# IAR project Project.ewp, settings and files
configuration STM32L4R9ZI-SensorTile101 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4R9xx; USE_HAL_DRIVER; STM32_SENSORTILE101
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\SensorTile.101; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\Drivers\BSP\Components\lis2mdl; ..\..\..\..\..\..\Drivers\BSP\Components\lps22hh; ..\..\..\..\..\..\Drivers\BSP\Components\lsm6dso; ..\..\..\..\..\..\Middlewares\ST\BlueNRG2\includes; ..\..\..\..\..\..\Middlewares\ST\BlueNRG2\hci\hci_tl_patterns\Basic; ..\..\..\..\..\..\Middlewares\ST\BlueNRG2\utils
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HelloWorldL4R9.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32l4r9xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
  group Drivers/BSP/SensorTile.101
    ../../../../../../Drivers/BSP/SensorTile.101/: SensorTile.101.c SensorTile.101_audio.c SensorTile.101_bc.c SensorTile.101_bus.c SensorTile.101_env_sensors.c SensorTile.101_env_sensors_ex.c SensorTile.101_motion_sensors.c SensorTile.101_motion_sensors_ex.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../Src/: system_stm32l4xx.c
  group Drivers/Middlewares/BlueNRG2/Controller
    ../../../../../../Middlewares/ST/BlueNRG2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
  group Drivers/Middlewares/BlueNRG2/HCI_TL/Basic
    ../../../../../../Middlewares/ST/BlueNRG2/hci/: bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
    ../../../../../../Middlewares/ST/BlueNRG2/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Drivers/Middlewares/BlueNRG2/Utils
    ../../../../../../Middlewares/ST/BlueNRG2/utils/: ble_list.c
  group HelloWorld/EWARM
    ./: startup_stm32l4r9xx.s
  group HelloWorld/User
    ../../Src/: hci_tl_interface.c hts221_ex.c lis2mdl_ex.c lps22hh_ex.c lsm6dso_ex.c main.c OTA.c stm32l4xx_it.c
