# Keil uVision project Project.uvprojx, settings and files
target SENSING1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475JEYx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SENSING1 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L475xx,USE_HAL_DRIVER,USE_STM32L475E_IOT01, PRIORITY_RTOS,ARM_MATH_CM4,__FPU_PRESENT=1
  c misc: --no_conditionalize --diag_suppress 1
  c include: ..\Inc;..\Patch;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\Drivers\CMSIS\DSP\Include;..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\B-L475E-IOT01;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes;..\..\..\..\..\Middlewares\ST\BlueNRG-MS\hci\hci_tl_patterns\Basic;..\..\..\..\..\Middlewares\ST\BlueNRG-MS\utils;..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\..\..\..\Middlewares\ST\STM32_AI_AudioPreprocessing_Library\Inc
  asm define: ARM_MATH_CM4
  asm misc: --cpreproc --cpreproc_opts=-D,ARM_MATH_CM4
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329 --diag_suppress=L6989
  group MDK-ARM
    ./: startup_stm32l475xx.s
  group User
    ../Src/: console.c DataLog_Manager.c hci_tl_interface.c main.c OTA.c PowerControl.c qspi_diskio_iot01.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c stm32l475e_iot01_bus_ex.c stm32l475e_iot01_env_sensors_ex.c stm32l475e_iot01_qspi_ex.c TargetPlatform.c usbd_conf.c usbd_desc.c usbd_audio_if.c usbd_storage_if.c cli_commands.c FreeRTOS_CLI.c ai_common.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis3mdl/: lis3mdl.c lis3mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c lsm6dsl_reg.c
    ../../../../../Drivers/BSP/Components/mx25r6435f/: mx25r6435f.c
  group Drivers/BSP/B-L475-IOT01
    ../../../../../Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_audio.c stm32l475e_iot01_bus.c stm32l475e_iot01_env_sensors.c stm32l475e_iot01_motion_sensors.c stm32l475e_iot01_qspi.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/CMSIS/DSP/Source/BasicMathFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/BasicMathFunctions/: arm_dot_prod_f32.c arm_negate_q15.c arm_add_q7.c arm_shift_q15.c arm_shift_q7.c arm_mult_f32.c
  group Drivers/CMSIS/DSP/Source/SupportFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/SupportFunctions/: arm_float_to_q7.c arm_float_to_q15.c arm_q7_to_float.c arm_q15_to_float.c arm_q7_to_q15.c arm_q15_to_q7.c arm_copy_q15.c arm_copy_q7.c arm_fill_q7.c arm_fill_q15.c
  group Drivers/CMSIS/DSP/Source/MatrixFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_init_f32.c
  group Drivers/CMSIS/DSP/Source/TransformFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/TransformFunctions/: arm_rfft_fast_init_f32.c arm_rfft_fast_f32.c arm_bitreversal.c arm_cfft_f32.c arm_cfft_radix8_f32.c arm_bitreversal2.S
  group Drivers/CMSIS/DSP/Source/ComplexMathFunctions
    ../../../../../Drivers/CMSIS/DSP/Source/ComplexMathFunctions/: arm_cmplx_mag_squared_f32.c
  group Drivers/CMSIS/DSP/Source/CommonTables
    ../../../../../Drivers/CMSIS/DSP/Source/CommonTables/: arm_common_tables.c
  group Drivers/STM32L4xx-HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c stm32l4xx_hal_exti.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/ST/STM32_BlueNRG
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/ST/STM32_USB_Device_Library
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/ST/STM32_AI_Library
    ../../../../../Middlewares/ST/STM32_AI_Library/lib/: NetworkRuntime410_CM4_Keil.lib
  group User/HAR
    ../Src/: har_Postprocessing.c har_Preprocessing.c har_Processing.c har_ProcessingTest.c har_gmp.c har_gmp_data.c har_ign.c har_ign_data.c har_ign_wsdm.c har_ign_wsdm_data.c
  group User/ASC
    ../Src/: asc_postprocessing.c asc_featurescaler.c asc_processing.c asc.c asc_data.c
  group Middlewares/ST/STM32_AI_AudioPreprocessing_Library
    ../../../../../Middlewares/ST/STM32_AI_AudioPreprocessing_Library/Src/: common_tables.c dct.c feature_extraction.c mel_filterbank.c window.c
  group Middlewares/Third_Party/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group User/Patch
    ../Patch/: usbd_audio_patch.c
