<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>Project</project>
                <configuration>B-L475E-IOT01 ASC</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>B-L475E-IOT01 HAR_GMP</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>B-L475E-IOT01 HAR_IGN</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>B-L475E-IOT01 HAR_IGN_WSDM</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
