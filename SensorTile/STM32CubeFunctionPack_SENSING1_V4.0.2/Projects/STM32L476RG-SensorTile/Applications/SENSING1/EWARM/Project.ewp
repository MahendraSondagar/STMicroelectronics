# IAR project Project.ewp, settings and files
configuration STM32L476RG-SensorTile (ARM)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; STM32_SENSORTILE; ARM_MATH_CM4; __FPU_PRESENT=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Inc; ..\Patch; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\DSP\Include; ..\..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\..\Drivers\BSP\SensorTile; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\..\Middlewares\ST\STM32_AI_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_AI_AudioPreprocessing_Library\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Drivers\BSP\Components\stc3115; ..\..\..\..\..\Drivers\BSP\Components\pcm1774; ..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\includes\; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\hci\hci_tl_patterns\Basic\; ..\..\..\..\..\Middlewares\ST\BlueNRG-MS\utils; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: SENSING1.bin
  ILINK.IlinkOutputFile: SENSING1_ST.out
  ILINK.IlinkIcfFile: stm32l476xG.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\Drivers\CMSIS\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
    ../../../../../Drivers/BSP/Components/lsm303agr/: lsm303agr.c lsm303agr_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsm/: lsm6dsm.c lsm6dsm_reg.c
    ../../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/BSP/SensorTile
    ../../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_audio.c SensorTile_bus.c SensorTile_env_sensors.c SensorTile_env_sensors_ex.c SensorTile_gg.c SensorTile_motion_sensors.c SensorTile_motion_sensors_ex.c SensorTile_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/BlueNRG-MS/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
  group Middlewares/BlueNRG-MS/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio_template.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/MetaDataManager
    ../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/STM32_AI_AudioPreprocessing_Library
    ../../../../../Middlewares/ST/STM32_AI_AudioPreprocessing_Library/Src/: common_tables.c dct.c feature_extraction.c mel_filterbank.c window.c
  group Middlewares/STM32_AI_Library
    ../../../../../Middlewares/ST/STM32_AI_Library/lib/: NetworkRuntime410_CM4_IAR.a
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group SENSING1/EWARM
    ./: startup_stm32l476xx.s
  group SENSING1/User
    ../Src/: ai_common.c cli_commands.c console.c DataLog_Manager.c FreeRTOS_CLI.c hci_tl_interface.c HWAdvanceFeatures.c main.c OTA.c PowerControl.c sd_diskio_SensorTile.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group SENSING1/User/ASC
    ../Src/: asc.c asc_data.c asc_featurescaler.c asc_postprocessing.c asc_processing.c
  group SENSING1/User/HAR
    ../Src/: har_gmp.c har_gmp_data.c har_ign.c har_ign_data.c har_ign_wsdm.c har_ign_wsdm_data.c har_Postprocessing.c har_Preprocessing.c har_Processing.c har_ProcessingTest.c
